# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__
  c misc: --c99
  c include: packages/ali-iotkit-latest/iotkit-embedded/src/infra;packages/ali-iotkit-latest/iotkit-embedded/src/mqtt/impl;packages/ali-iotkit-latest/iotkit-embedded/src/mqtt;packages/ali-iotkit-latest/iotkit-embedded/src/dev_sign;packages/ali-iotkit-latest/iotkit-embedded/src/ota;packages/ali-iotkit-latest/iotkit-embedded/wrappers;applications;.;../../../components/net/at/include;../../../components/net/at/at_socket;packages/at_device-latest/inc;packages/at_device-latest/class/ec200x;board;packages/cJSON-v1.7.14;../../../libcpu/arm/common;../../../libcpu/arm/arm926;../../../components/drivers/include;../../../components/drivers/hwcrypto;.;../../../components/drivers/include;../../../components/drivers/include;../../../components/drivers/spi;../../../components/drivers/include;../../../components/drivers/include;../../../components/drivers/include;../../../components/drivers/include;../../../components/drivers/include;../../../components/drivers/include;../../../components/drivers/include;../libraries/nuc980/rtt_port;../../../components/dfs/include;../../../components/dfs/filesystems/elmfat;../../../components/dfs/filesystems/devfs;../../../components/finsh;packages/freemodbus-latest/modbus/include;packages/freemodbus-latest/modbus/rtu;packages/freemodbus-latest/modbus/ascii;packages/freemodbus-latest/modbus/tcp;packages/freemodbus-latest/port;.;../../../include;../../../components/libc/compilers/armlibc;../../../components/libc/compilers/common;../../../components/libc/compilers/common/none-gcc;../libraries/nuc980/Driver/Include;../../../components/net/lwip-2.0.2/src;../../../components/net/lwip-2.0.2/src/include;../../../components/net/lwip-2.0.2/src/include/ipv4;../../../components/net/lwip-2.0.2/src/arch/include;../../../components/net/lwip-2.0.2/src/include/netif;packages/mem_sandbox-latest;packages/netutils-latest/tftp;.;../libraries/nu_packages/Demo;../libraries/nu_packages/SPINAND;../libraries/nuc980/UsbHostLib/inc;../libraries/nu_packages/NuUtils/inc;packages/optparse-latest;packages/easyblink-latest;packages/ramdisk-latest/inc;../../../components/drivers/usb/usbhost;../../../components/drivers/usb/usbhost/class;../../../components/drivers/usb/usbhost/core;../../../components/drivers/usb/usbhost/include;../../../components/drivers/include;../../../components/net/sal_socket/include;../../../components/net/sal_socket/include/socket;../../../components/net/sal_socket/impl;../../../components/net/sal_socket/include/dfs_net;../../../components/net/sal_socket/include/dfs_net/sys_select;../../../components/net/sal_socket/include/socket/sys_socket;../../../components/net/netdev/include;packages/uffs-latest;packages/uffs-latest/src/inc;../../../components/utilities/utest;../../../components/utilities/ulog;../../../components/utilities/ymodem;packages/webclient-latest/inc;packages/webclient-v2.1.2/inc
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\nuc980.sct
  group ali-iotkit
    packages/ali-iotkit-latest/ports/rtthread/: HAL_OS_rtthread.c HAL_UDP_rtthread.c HAL_TCP_rtthread.c
    packages/ali-iotkit-latest/iotkit-embedded/src/infra/: infra_md5.c infra_report.c infra_compat.c infra_timer.c infra_defs.c infra_json_parser.c infra_net.c infra_string.c infra_sha256.c infra_httpc.c
    packages/ali-iotkit-latest/iotkit-embedded/src/mqtt/impl/: MQTTConnectClient.c iotx_mqtt_client.c MQTTUnsubscribeClient.c MQTTSubscribeClient.c MQTTSerializePublish.c MQTTDeserializePublish.c MQTTPacket.c
    packages/ali-iotkit-latest/samples/mqtt/: mqtt-example.c
    packages/ali-iotkit-latest/iotkit-embedded/src/ota/: iotx_ota.c ota_lib.c ota_fetch.c
    packages/ali-iotkit-latest/iotkit-embedded/src/mqtt/: mqtt_api.c
    packages/ali-iotkit-latest/ports/: wrapper.c
    packages/ali-iotkit-latest/iotkit-embedded/src/dev_sign/: dev_sign_mqtt.c
    packages/ali-iotkit-latest/samples/ota/: ota_mqtt-example.c
  group Applications
    applications/: main.c mnt.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_cli.c at_client.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/samples/: at_sample_ec200x.c
    packages/at_device-latest/class/ec200x/: at_device_ec200x.c at_socket_ec200x.c
    packages/at_device-latest/src/: at_device.c
  group board
    board/: nu_pin_init.c board_dev.c
  group cJSON
    packages/cJSON-v1.7.14/: cJSON.c cJSON_Utils.c cJSON_port.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/arm926/: context_rvds.S machine.c cpuport.c mmu.c stack.c start_rvds.S trap.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/hwcrypto/: hwcrypto.c hw_rng.c hw_hash.c hw_symmetric.c
    ../../../components/drivers/i2c/: i2c_dev.c i2c_core.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/spi/: spi_dev.c qspi_core.c spi_core.c
    ../../../components/drivers/watchdog/: watchdog.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/mtd/: mtd_nand.c
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: dataqueue.c completion.c pipe.c ringblk_buf.c waitqueue.c workqueue.c ringbuffer.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_wdt.c drv_usbhost.c drv_pwm.c drv_etimer.c drv_i2c.c drv_can.c drv_sys.c drv_ebi.c drv_emac.c drv_common.c drv_uart.c drv_sdh.c drv_rtc.c drv_systick.c drv_crypto.c drv_pdma.c drv_adc.c drv_i2s.c drv_usbd.c drv_gpio.c drv_qspi.c drv_spi.c drv_scuart.c drv_softi2c.c drv_etimer_capture.c
  group Filesystem
    ../../../components/dfs/src/: select.c poll.c dfs_fs.c dfs.c dfs_file.c dfs_posix.c
    ../../../components/dfs/filesystems/elmfat/: ff.c ffunicode.c dfs_elm.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group finsh
    ../../../components/finsh/: cmd.c msh.c finsh_error.c finsh_token.c finsh_heap.c finsh_init.c finsh_node.c finsh_compiler.c msh_file.c finsh_ops.c finsh_vm.c shell.c finsh_var.c finsh_parser.c
  group FreeModbus
    packages/freemodbus-latest/modbus/functions/: mbfuncholding_m.c mbfuncdisc.c mbfuncinput.c mbutils.c mbfuncdisc_m.c mbfunccoils.c mbfuncinput_m.c mbfuncother.c mbfunccoils_m.c mbfuncdiag.c mbfuncholding.c
    packages/freemodbus-latest/port/: user_mb_app_m.c portevent_m.c porttimer.c portserial_m.c portevent.c user_mb_app.c portserial.c port.c porttimer_m.c
    packages/freemodbus-latest/modbus/rtu/: mbrtu.c mbcrc.c mbrtu_m.c
    packages/freemodbus-latest/modbus/: mb_m.c mb.c
    packages/freemodbus-latest/modbus/ascii/: mbascii.c
    packages/freemodbus-latest/samples/: sample_mb_slave.c sample_mb_master.c
  group Kernel
    ../../../src/: ipc.c components.c device.c object.c mem.c scheduler.c irq.c memheap.c mempool.c idle.c timer.c signal.c thread.c clock.c kservice.c
  group libc
    ../../../components/libc/compilers/armlibc/: stdio.c syscalls.c libc.c mem_std.c
    ../../../components/libc/compilers/common/: stdlib.c time.c unistd.c
  group Libraries
    ../libraries/nuc980/Driver/Source/: nu_spi.c nu_scuart.c nu_usbd.c nu_cap.c nu_i2c.c nu_qspi.c nu_wdt.c nu_pdma.c nu_etimer.c nu_crypto.c nu_emac.c nu_wwdt.c nu_sdh.c nu_i2s.c nu_sys.c nu_ebi.c nu_uart.c nu_rtc.c nu_gpio.c nu_can.c
  group lwIP
    ../../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../../components/net/lwip-2.0.2/src/core/ipv4/: ip4_frag.c ip4.c etharp.c dhcp.c icmp.c ip4_addr.c autoip.c igmp.c
    ../../../components/net/lwip-2.0.2/src/api/: tcpip.c err.c api_lib.c sockets.c netdb.c netbuf.c api_msg.c netifapi.c
    ../../../components/net/lwip-2.0.2/src/core/: sys.c tcp_out.c inet_chksum.c tcp.c raw.c netif.c tcp_in.c init.c ip.c stats.c timeouts.c pbuf.c memp.c udp.c def.c dns.c
    ../../../components/net/lwip-2.0.2/src/netif/: lowpan6.c ethernetif.c ethernet.c
    ../../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group mem_sandbox
    packages/mem_sandbox-latest/: mem_sandbox.c
  group NetUtils
    packages/netutils-latest/tftp/: tftp_server.c tftp_port.c tftp_xfer.c tftp_client.c
    packages/netutils-latest/iperf/: iperf.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_hid_dance_mouse.c usbd_cdc_vcom_echo.c slcd_show_tick.c
  group nu_pkgs_spinand
    ../libraries/nu_packages/SPINAND/: spinand.c drv_spinand.c
  group nuc980_usbhostlib
    ../libraries/nuc980/UsbHostLib/src/: mem_alloc.c ehci_iso.c usb_core.c ehci.c ohci.c support.c
  group optparse
    packages/optparse-latest/: optparse.c
  group Packages
    packages/easyblink-latest/: easyblink.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost_core.c driver.c usbhost.c
    ../../../components/drivers/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal_socket/impl/: af_inet_at.c af_inet_lwip.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
  group uffs
    packages/uffs-latest/src/uffs/: uffs_crc.c uffs_utils.c uffs_debug.c uffs_init.c uffs_pool.c uffs_fd.c uffs_blockinfo.c uffs_device.c uffs_version.c uffs_buf.c uffs_flash.c uffs_public.c uffs_mtb.c uffs_mem.c uffs_fs.c uffs_find.c uffs_badblock.c uffs_ecc.c uffs_tree.c
    packages/uffs-latest/: uffs_rtthread.c uffs_nandif.c dfs_uffs.c
  group UTest
    ../../../components/utilities/utest/: utest.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
    ../../../components/utilities/ymodem/: ymodem.c
  group WebClient
    packages/webclient-latest/samples/: webclient_get_sample.c webclient_post_sample.c
    packages/webclient-latest/src/: webclient_file.c webclient.c
