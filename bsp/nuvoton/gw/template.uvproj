# Keil uVision project template.uvproj, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_INTERRUPT_INFO
  c misc: --c99
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\linking_scripts\nuc980.sct
