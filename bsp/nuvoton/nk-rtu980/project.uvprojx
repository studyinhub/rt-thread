# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;board;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\arm926;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\nuc980\rtt_port;packages\fal-latest\inc;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\none-gcc;..\libraries\nuc980\Driver\Include;..\..\..\components\net\lwip-2.0.2\src;..\..\..\components\net\lwip-2.0.2\src\include;..\..\..\components\net\lwip-2.0.2\src\include\ipv4;..\..\..\components\net\lwip-2.0.2\src\arch\include;..\..\..\components\net\lwip-2.0.2\src\include\netif;packages\mem_sandbox-latest;packages\netutils-v1.2.0\ntp;packages\netutils-v1.2.0\tftp;.;packages\netutils-v1.2.0\iperf;..\libraries\nu_packages\Demo;..\libraries\nuc980\UsbHostLib\inc;..\libraries\nu_packages\NuUtils\inc;packages\optparse-latest;packages\ramdisk-latest\inc;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\components\net\netdev\include;..\..\..\components\utilities\utest
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\nuc980.sct
  group Applications
    applications/: main.c mnt.c
  group board
    board/: board_dev.c nu_pin_init.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/arm926/: mmu.c start_rvds.S machine.c stack.c context_rvds.S trap.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: adc.c pin.c
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_hash.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../../components/drivers/watchdog/: watchdog.c
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: waitqueue.c workqueue.c pipe.c dataqueue.c ringbuffer.c completion.c ringblk_buf.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_etimer.c drv_systick.c drv_wdt.c drv_sdh.c drv_can.c drv_sys.c drv_i2c.c drv_usbd.c drv_gpio.c drv_qspi.c drv_uart.c drv_rtc.c drv_spi.c drv_softi2c.c drv_etimer_capture.c drv_common.c drv_emac.c drv_pwm.c drv_pdma.c drv_scuart.c drv_ebi.c drv_usbhost.c drv_i2s.c drv_adc.c drv_crypto.c
  group fal
    packages/fal-latest/samples/porting/: fal_flash_sfud_port.c
    packages/fal-latest/src/: fal.c fal_rtt.c fal_partition.c fal_flash.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_file.c select.c dfs.c poll.c dfs_fs.c
    ../../../components/dfs/filesystems/elmfat/: ff.c ffunicode.c dfs_elm.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group finsh
    ../../../components/finsh/: finsh_node.c msh.c finsh_parser.c cmd.c finsh_vm.c msh_file.c shell.c finsh_var.c finsh_compiler.c finsh_heap.c finsh_ops.c finsh_error.c finsh_token.c finsh_init.c
  group Kernel
    ../../../src/: mempool.c irq.c kservice.c signal.c components.c idle.c mem.c thread.c clock.c scheduler.c memheap.c object.c device.c timer.c ipc.c
  group libc
    ../../../components/libc/compilers/armlibc/: syscalls.c mem_std.c stdio.c libc.c
    ../../../components/libc/compilers/common/: unistd.c stdlib.c time.c
  group Libraries
    ../libraries/nuc980/Driver/Source/: nu_rtc.c nu_i2s.c nu_can.c nu_emac.c nu_etimer.c nu_uart.c nu_pdma.c nu_wwdt.c nu_gpio.c nu_sys.c nu_crypto.c nu_usbd.c nu_spi.c nu_qspi.c nu_cap.c nu_ebi.c nu_i2c.c nu_wdt.c nu_scuart.c nu_sdh.c
  group lwIP
    ../../../components/net/lwip-2.0.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    ../../../components/net/lwip-2.0.2/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    ../../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group mem_sandbox
    packages/mem_sandbox-latest/: mem_sandbox.c
  group NetUtils
    packages/netutils-v1.2.0/ntp/: ntp.c
    packages/netutils-v1.2.0/tftp/: tftp_client.c tftp_xfer.c tftp_server.c tftp_port.c
    packages/netutils-v1.2.0/iperf/: iperf.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c slcd_show_tick.c usbd_hid_dance_mouse.c
  group nuc980_usbhostlib
    ../libraries/nuc980/UsbHostLib/src/: ehci.c usb_core.c support.c ehci_iso.c ohci.c mem_alloc.c
  group optparse
    packages/optparse-latest/: optparse.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/class/: mstorage.c cdc_vcom.c
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
    ../../../components/drivers/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/sal_socket/impl/: af_inet_lwip.c
    ../../../components/net/sal_socket/socket/: net_sockets.c net_netdb.c
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
  group UTest
    ../../../components/utilities/utest/: utest.c
  group vi
    packages/vi-latest/: vi.c vi_utils.c
