# Keil uVision project template.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\nuc980.sct
