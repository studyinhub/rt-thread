# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;board;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\arm926;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\nuc980\rtt_port;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\none-gcc;..\libraries\nuc980\Driver\Include;..\..\..\components\net\lwip-2.0.2\src;..\..\..\components\net\lwip-2.0.2\src\include;..\..\..\components\net\lwip-2.0.2\src\include\ipv4;..\..\..\components\net\lwip-2.0.2\src\arch\include;..\..\..\components\net\lwip-2.0.2\src\include\netif;packages\mem_sandbox-latest;packages\netutils-v1.3.0\ntp;packages\netutils-v1.3.0\tftp;.;packages\netutils-v1.3.0\iperf;..\libraries\nu_packages\Demo;..\libraries\nu_packages\AudioCodec;..\libraries\nu_packages\SPINAND;..\libraries\nuc980\UsbHostLib\inc;..\libraries\nu_packages\NuUtils\inc;packages\optparse-latest;packages\ramdisk-latest\inc;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\components\net\netdev\include;packages\uffs-latest;packages\uffs-latest\src\inc;..\..\..\components\utilities\utest
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\nuc980.sct
  group Applications
    applications/: main.c mnt.c
  group board
    board/: board_dev.c nu_pin_init.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/arm926/: mmu.c cpuport.c stack.c trap.c start_rvds.S machine.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c pin.c
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_hash.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c
    ../../../components/drivers/audio/: audio_pipe.c audio.c
    ../../../components/drivers/watchdog/: watchdog.c
    ../../../components/drivers/rtc/: rtc.c alarm.c
    ../../../components/drivers/mtd/: mtd_nand.c
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringbuffer.c waitqueue.c completion.c dataqueue.c workqueue.c pipe.c ringblk_buf.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_pdma.c drv_uart.c drv_wdt.c drv_ebi.c drv_etimer.c drv_usbhost.c drv_sdh.c drv_common.c drv_crypto.c drv_emac.c drv_qspi.c drv_sys.c drv_systick.c drv_i2s.c drv_usbd.c drv_can.c drv_softi2c.c drv_adc.c drv_rtc.c drv_scuart.c drv_i2c.c drv_spi.c drv_gpio.c drv_pwm.c drv_etimer_capture.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_file.c select.c dfs.c poll.c dfs_fs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ffunicode.c ff.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group finsh
    ../../../components/finsh/: finsh_node.c finsh_parser.c cmd.c finsh_vm.c msh_file.c msh.c shell.c finsh_var.c finsh_compiler.c finsh_heap.c finsh_ops.c finsh_error.c finsh_token.c finsh_init.c
  group Kernel
    ../../../src/: signal.c memheap.c mem.c components.c object.c thread.c kservice.c device.c mempool.c scheduler.c irq.c ipc.c timer.c clock.c idle.c
  group libc
    ../../../components/libc/compilers/armlibc/: stdio.c libc.c mem_std.c syscalls.c
    ../../../components/libc/compilers/common/: stdlib.c unistd.c time.c
  group Libraries
    ../libraries/nuc980/Driver/Source/: nu_etimer.c nu_usbd.c nu_cap.c nu_sys.c nu_gpio.c nu_sdh.c nu_crypto.c nu_can.c nu_i2c.c nu_ebi.c nu_scuart.c nu_rtc.c nu_spi.c nu_emac.c nu_uart.c nu_pdma.c nu_wwdt.c nu_wdt.c nu_i2s.c nu_qspi.c
  group lwIP
    ../../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
    ../../../components/net/lwip-2.0.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    ../../../components/net/lwip-2.0.2/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    ../../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
  group mem_sandbox
    packages/mem_sandbox-latest/: mem_sandbox.c
  group NetUtils
    packages/netutils-v1.3.0/ntp/: ntp.c
    packages/netutils-v1.3.0/tftp/: tftp_xfer.c tftp_port.c tftp_server.c tftp_client.c
    packages/netutils-v1.3.0/iperf/: iperf.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c slcd_show_tick.c usbd_hid_dance_mouse.c
  group nu_pkgs_nau8822
    ../libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau8822.c
  group nu_pkgs_spinand
    ../libraries/nu_packages/SPINAND/: spinand.c drv_spinand.c
  group nuc980_usbhostlib
    ../libraries/nuc980/UsbHostLib/src/: usb_core.c support.c ehci_iso.c mem_alloc.c ohci.c ehci.c
  group optparse
    packages/optparse-latest/: optparse.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/class/: mstorage.c cdc_vcom.c
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/class/: udisk.c mass.c
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/socket/: net_sockets.c net_netdb.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../../components/net/sal_socket/impl/: af_inet_lwip.c
    ../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
  group uffs
    packages/uffs-latest/src/uffs/: uffs_mem.c uffs_mtb.c uffs_crc.c uffs_tree.c uffs_flash.c uffs_version.c uffs_debug.c uffs_blockinfo.c uffs_public.c uffs_find.c uffs_buf.c uffs_pool.c uffs_device.c uffs_fd.c uffs_utils.c uffs_ecc.c uffs_badblock.c uffs_init.c uffs_fs.c
    packages/uffs-latest/: uffs_nandif.c uffs_rtthread.c dfs_uffs.c
  group UTest
    ../../../components/utilities/utest/: utest.c
